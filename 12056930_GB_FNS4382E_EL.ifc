Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-01-04T11:36:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 04 11:36:36 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\65144e2e-6c02-4ec3-a9f7-b7ba11816c6d\674ef631-a79b-4245-bdb7-647e2668dc50\ifc * Database version: 5507 * Database creation date: Wed Jan 04 11:36:35 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 04 11:36:36 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 04 11:36:36 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12056930_GB_FNS4382E_EL:37438251_GB_12056930_FNS4382E_EL, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black
Type - Pset_BuildingElementProxyCommon - Reference: 37438251_GB_12056930_FNS4382E_EL
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Freezers / freezers
Type - Pset_QuantityTakeOff - Reference: 37438251_GB_12056930_FNS4382E_EL
Type - Pset_ProvisionForVoid - Width: 600 mm; Height: 1855 mm; Depth: 675 mm
Material: z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Connection_Modul, z_Miele_Design_Glass, z_Miele_Design_BRWS
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_355373
Description: Flow; FlowDirection: SOURCEANDSINK
